Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2022-01-05T08:03:44
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.0.1169.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 05 08:03:44 2022 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\{7F5FDC24-54EE-4160-8AAD-885446BF0CBC}\ifc * Database version: 5507 * Database creation date: Wed Jan 05 08:03:43 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 05 08:03:43 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 05 08:03:43 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 28269855_USA_10876810_DA2698_EDST, 10876810_USA_DA2698_EDST:28269855_USA_10876810_DA2698_EDST:210839
In: Level 1
Type - Material: z_Miele_Design_CLST, z_Miele_Connection_Electric, z_Miele_Connection_ExhaustAir, Aluminum, z_Miele_Design_Glass
Pset_BuildingElementProxyCommon - Reference: 28269855_USA_10876810_DA2698_EDST
Pset_ManufacturerTypeInformation - Manufacturer: Miele
